# Keil uVision project RazorClamDICE.uvprojx, settings and files
target RazorClamDICE (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: RazorClamDICE
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,TISI2C,WOLFSSL_USER_SETTINGS,TPMI2CBUSHANDLE=hi2c1,TPMSPIBUSHANDLE=hspi3,STM32L476xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Inc;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;../Drivers/TisTpmDrv;../Middlewares/WolfSSL-3.8.0;../Middlewares/Urchin/inc;../Middlewares/CryptoApi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Src/: usbd_dfu.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Application/User
    ../Src/: usbd_desc.c stm32l4xx_it.c stm32l4xx_hal_timebase_TIM.c main.c usb_device.c stm32l4xx_hal_msp.c usbd_conf.c usbd_dfu_if.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_dma.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_tim.c stm32l4xx_hal.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_pcd_ex.c stm32l4xx_ll_usb.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_flash.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_pwr.c stm32l4xx_hal_rng.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_uart.c
  group Drivers/TisTpmDrv
    ../Drivers/TisTpmDrv/: TisTpmDrv.c TisTpmDrv.h
  group Middlewares/WolfSSL
    ../Middlewares/WolfSSL-3.8.0/wolfcrypt/src/: aes.c hmac.c integer.c random.c sha.c sha256.c sha512.c logging.c memory.c
  group Middlewares/CryptoAPI
    ../Middlewares/CryptoAPI/: CryptoApi.cpp
  group Application/UserCPP
    ../Src/: Test.cpp
    ../Inc/: Test.h
    ./: Exception.cpp
  group Middlewares/Urchin
    ../Middlewares/Urchin/Platform/: Platform.cpp
    ../Middlewares/Urchin/Lib/: ActivateCredential.cpp Certify.cpp CertifyCreation.cpp ChangeEPS.cpp ChangePPS.cpp Clear.cpp ClearControl.cpp ClockRateAdjust.cpp ClockSet.cpp CmdProcessor.cpp CommandCodeAttributesTables.cpp Commit.cpp ContextLoad.cpp ContextSave.cpp CpriHash.cpp CpriSym.cpp Create.cpp CreatePrimary.cpp CryptUtil.cpp DictionaryAttackLockReset.cpp DictionaryAttackParameters.cpp Duplicate.cpp EC_Ephemeral.cpp ECC_Parameters.cpp ECDH_KeyGen.cpp ECDH_ZGen.cpp EncryptDecrypt.cpp EventSequenceComplete.cpp EvictControl.cpp FieldUpgradeData.cpp FieldUpgradeStart.cpp FirmwareRead.cpp FlushContext.cpp GetCapability.cpp GetCommandAuditDigest.cpp GetRandom.cpp GetSessionAuditDigest.cpp GetTestResult.cpp GetTime.cpp Hash.cpp HashSequenceStart.cpp HierarchyChangeAuth.cpp HierarchyControl.cpp HMAC.cpp HMAC_Start.cpp Import.cpp IncrementalSelfTest.cpp Load.cpp LoadExternal.cpp MakeCredential.cpp Marshal.cpp MemoryLib.cpp NV_Certify.cpp NV_ChangeAuth.cpp NV_DefineSpace.cpp NV_Extend.cpp NV_GlobalWriteLock.cpp NV_Increment.cpp NV_Read.cpp NV_ReadLock.cpp NV_ReadPublic.cpp NV_SetBits.cpp NV_UndefineSpace.cpp NV_UndefineSpaceSpecial.cpp NV_Write.cpp NV_WriteLock.cpp ObjectChangeAuth.cpp PCR_Allocate.cpp PCR_Event.cpp PCR_Extend.cpp PCR_Read.cpp PCR_Reset.cpp PCR_SetAuthPolicy.cpp PCR_SetAuthValue.cpp PolicyAuthorize.cpp PolicyAuthValue.cpp PolicyCommandCode.cpp PolicyCounterTimer.cpp PolicyCpHash.cpp PolicyDuplicationSelect.cpp PolicyGetDigest.cpp PolicyLocality.cpp PolicyNameHash.cpp PolicyNV.cpp PolicyOR.cpp PolicyPassword.cpp PolicyPCR.cpp PolicyPhysicalPresence.cpp PolicyRestart.cpp PolicySecret.cpp PolicySigned.cpp PolicyTicket.cpp PP_Commands.cpp Quote.cpp ReadClock.cpp ReadPublic.cpp Rewrap.cpp RSA_Decrypt.cpp RSA_Encrypt.cpp SelfTest.cpp SequenceComplete.cpp SequenceUpdate.cpp SetAlgorithmSet.cpp SetCommandCodeAuditStatus.cpp SetPrimaryPolicy.cpp Shutdown.cpp Sign.cpp StartAuthSession.cpp Startup.cpp stdafx.cpp StirRandom.cpp TestParms.cpp Unseal.cpp VerifySignature.cpp ZGen_2Phase.cpp
    ../Middlewares/Urchin/Inc/: UrchinLib.h UrchinPlatform.h
software components: CMSIS:CORE 4.1.0
